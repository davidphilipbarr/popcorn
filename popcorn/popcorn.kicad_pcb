# Repository davidphilipbarr/popcorn

File README.md:

# Popcorn
36 key corne thing with more pinky stagger.

## KiCad design popcorn/popcorn.kicad_pcb

Board: 2 copper layers, 112.4 x 88.7 mm, 55 parts (4 on the bottom side), 37 nets.

Parts:
D2, D3, D4, D5, D6, D8, D9, D10, D11, D12, D14, D15, D16, D17, D18, D19, D20, D21: D; D3_TH_SMD
H1: h1; LEGO_HOLE
J1: MJ-4PP-9
J2: OLED
JP6, JP61: SDA; Jumper
JP62, JP68: GND; Jumper
JP63, JP66: SCL; Jumper
JP64, JP65: VCC; Jumper
RSW1: Val**; ResetSW
SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW19, SW20: SW_PUSH; SW_PG1350_reversible_b2
SW21: SW_PUSH; SW_PG1350_rev_DPB
U1: ProMicro; ProMicro_v2
h2, h2#2, h2#3, h2#4, h2#5, h2#6: h2; LEGO_HOLE

Connections:
GND: J1.C, JP62.1, JP68.1, RSW1.1, U1.3, U1.4, U1.23
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
unnamed: J2.3, JP65.2, JP66.2
unnamed: J2.4, JP6.2, JP68.2
unnamed: J2.2, JP63.2, JP64.2
unnamed: J2.1, JP61.2, JP62.2
SCL: JP63.1, JP66.1, U1.6
SDA: JP6.1, JP61.1, U1.5
VCC: J1.D, JP64.1, JP65.1, U1.21
col1: SW2.1, SW8.1, SW14.1, U1.19
col2: SW3.1, SW9.1, SW15.1, U1.18
col3: SW4.1, SW10.1, SW16.1, SW19.1, U1.17
col4: SW5.1, SW11.1, SW17.1, SW20.1, U1.16
col5: SW6.1, SW12.1, SW18.1, SW21.1, U1.15
data: J1.B, U1.2
reset: RSW1.2, U1.22
row0: D2.1, D3.1, D4.1, D5.1, D6.1, U1.7
row1: D8.1, D9.1, D10.1, D11.1, D12.1, U1.8
row2: D14.1, D15.1, D16.1, D17.1, D18.1, U1.9
row3: D19.1, D20.1, D21.1, U1.10

## Commit log

2021-12-06 Cleaned up Silkscreen
    Cleaned up Silkscreen and added what it's called and who its made by. (Popcorn made by David Barr)
2021-12-06 Update popcorn.png
    Update image to reflect update silkscreen.
2021-12-06 Update README.md
    Added image of PCB.
